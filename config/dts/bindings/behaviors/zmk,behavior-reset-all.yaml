## config/dts/bindings/behaviors/zmk,behavior-reset-all.yaml
```yaml
description: Reset the split peripheral and then the central
compatible: "zmk,behavior-reset-all"
include: zero_param.yaml
```
